# Keil uVision project USART.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\ADC;..\HARDWARE\BEEP;..\HARDWARE\EXTI;..\HARDWARE\TIMER;..\HARDWARE\Modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group1
    ./: startup_stm32f10x_md.s
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Modbus/: modbus.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: README.TXT
